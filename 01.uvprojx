# Keil uVision project 01.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 01 +hex
  c flags: Optim=4 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\cmsis;.\interrupt;.\inc;.\n_os\include;.\n_os\chip;.\include;.\debug;.\n_boot
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./boot/: startup_stm32f10x_cl.s
  group lib
    ./lib/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group sys
    ./cmsis/: core_cm3.c system_stm32f10x.c
    ./interrupt/: stm32f10x_it.c
    ./sys/: os_cpu_a.asm
  group my
    ./: main.c
    ./sys/: sys.c
  group debug
    ./debug/: debug.c
  group include
    ./include/: all.h sys.h
  group n_boot
    ./n_boot/: boot.c cpu_c.c xmodem.c command.c flash.c xmodem_crc16.c xmodem_hw.c
